# Repository dhairyashah1/USBee32-S2

File README.md:

# USBee32-S2 : ESP32-S2 Hardware Design

<p align="center">

  </br>
</p>

</br>
This repository contains hardware design files and datasheets for the ESP32-S2. This is an open source ESP32-S2 based PCB with breakout ports for both USB - Type A and USB - Type C.
</br>

## Features

* Small form factor of 68.4mm x 27.9mm
* Four layered customly designed general purpose Development board
* Uses ESP32-S2-WROOM RF module
* Breakout ports for both USB - Type A and USB - Type C
* Uses CH340C which gives a high current output converting USB to UART logic
* Powering modes for the ESP - Either can be used
  - USB - A: Using a USB A Male Cable
  - USB - C: Using a USB C Male Cable(Typical Mobile charger cable)
  - VI Pin: Supplying this GPIO pin with external 5V
* Has a On - board debuggable Neopixel (RGB Led)
* Has an ESD protection device which protects the circuit from electrostatic discharge and prevents malfunction/breakdown of the device
* Uses MCP73831 for charging LiPo battery
* Can use it as a power/communicating device for a joystick/ game controller
* Space efficient PCB with integrating majority components in SMD type package 

## Project Structure

```
/assets/datasheets  - contains datasheets of various components used in the PCB
/assets/references  - contains references for the PCB
/assets/schematics  - contains schematics of the the PCB
/assets/screenshots - contains screenshots of the the PCB
.
├── assets
│   ├── datasheets   - contains datasheets of various components used in the PCB         
│   ├── references   - contains references used in making the PCB
│   ├── schematics   - contains schematics of the PCB
│   └── screenshots  - contains screenshots of the PCB
├── gerbers          - contains exportable gerber files of the PCB
├── renders          - contains models and renders of the PCB
└── USBee32-S2       
    ├── component_libraries  - contains external component libraries used 
    └── ...                  - various KiCAD PCB files
```

## Tools

To view/modify the files from this repository, install KiCAD from: [https://kicad.org](https://kicad.org)

## Schematics

## Plots
### Front side

### Back side

## Future work

- [x] Switching to a 4-layer PCB to make it more space efficient
- [x] Adding safety against electrostatic discharge (ESD)
- [x] Adding Neopixel RBG Leds
- [x] Adding Battery charging circuit
- [x] Adding Safety against ESD - Electrostatic Discharge
- [ ] Adding extra components to the board to deliver better functionality (Eg: OLED)
- [ ] Adding various general purpose sensors 
- [ ] Adding Firmware support

## Documentation
- Click [here](https://dhairyashah1.github.io/USBee32-S2/) to view

## Bill of Materials
- Click [here](https://docs.google.com/spreadsheets/d/1pFtIJ-MqmLt7VhAe4oJemrvx9vsikKc4zFzRtyDyzKU/) to view

<!-- CONTRIBUTORS -->
## Contributors

- [Dhairya Shah](https://github.com/dhairyashah1): *Designer*
- [Chaitravi Chalke](https://github.com/chaitravi-ce): *Designer*
- [Sakshi Chikshe](https://github.com/Sakshi-0311): *Designer*
- [Vedant Paranjape](https://github.com/VedantParanjape): *Mentor*
- [Omkar Bhilare](https://github.com/ombhilare999): *Mentor*

## Sponsorship
- Thanks to PCBWay for sponsoring the first Prototypes.

## Organization
- [SRA-VJTI](https://github.com/SRA-VJTI)

## License
- Distributed under the [MIT License](https://github.com/dhairyashah1/pcb-design-ESP32-S2/blob/main/LICENSE).

## KiCad design USBee32-S2/USBee32-S2.kicad_pcb

Parts:
C1, C2, C4, C5, C7, C10, C11, C12: 0.1uF; C_0603_1608Metric
C3, C9: 10uF; C_0603_1608Metric
C6: 10 uF; C_0603_1608Metric
C8: 22 uF; C_0603_1608Metric
D1: 1N5819; D_1206_3216Metric
D2, D3: LED; LED_0603_1608Metric_Castellated
D4: WS2812B; WS2812B2020
F1: Polyfuse_Small; Fuse_1206_3216Metric
J1: USB_A; USB_A_Wuerth_614004134726_Horizontal
J2: TYPE-C-31-M-12; HRO_TYPE-C-31-M-12; PARTREV A
J3: Conn_01x18_Male; PinHeader_1x18_P2.54mm_Vertical
J4: B2B-PH-SM4-TB(LF)(SN); JST_B2B-PH-SM4-TB(LF)(SN)
J5: Conn_01x22_Male; PinHeader_1x22_P2.54mm_Vertical
Q1, Q2: MMBT8050
R1, R2, R4, R5, R9, R10: 10K; R_0603_1608Metric
R3, R6: 5.1K; R_0603_1608Metric
R7, R8: 100k; R_0603_1608Metric
R11, R12, R13: 1k; R_0603_1608Metric
R14: 4.7k; R_0603_1608Metric
SW1, SW2: SW_Push; tactile_smd_switch
U1: ESP32-S2-WROOM-ESP32-S2-WROOM; ESP32S2WROOMM22S2H3200PH3Q0; PARTREV V1.0
U2: MCP73831-2-OT; SOT-23-5
U3: AMS1117-3.3; SOT-223-3_TabPin2
U4: CH340C; SOIC-16_3.9x9.9mm_P1.27mm
U5: IP4220CZ6; SOP95P275X110-6N; Manufacturer_Part_Number IP4220CZ6; Mouser Part Number N/A

Connections:
+3V3: C2.1, C3.1, C8.2, C10.2, C11.1, D2.2 (A), J3.2, J5.17, R1.1, R2.1, R9.2, R10.2, U1.2 (3V3), U3.2 (VO), U4.16 (VCC)
/CC1: J2.A5 (CC1), R3.1
/CC2: J2.B5 (CC2), R6.1
/CHIP_PU: C1.1, C5.2, Q1.3, R2.2, R10.1, SW2.2, U1.41 (EN)
/D1+: J1.3 (D+), J5.19, U1.23 (IO20), U5.1 (I/O_1)
/D1-: J1.2 (D-), J5.20, U1.22 (IO19), U5.6 (I/O_4)
/DN1: J2.A7 (DN1), J2.B7 (DN2), U4.6 (UD-), U5.3 (I/O_2)
/DP1: J2.A6 (DP1), J2.B6 (DP2), U4.5 (UD+), U5.4 (I/O_3)
/GPIO_0: C4.2, Q2.3, R9.1, SW1.2, U1.3 (IO0)
/GPIO_1: J3.3, U1.4 (IO1)
/GPIO_2: J3.4, U1.5 (IO2)
/GPIO_3: J3.5, U1.6 (IO3)
/GPIO_4: J3.6, U1.7 (IO4)
/GPIO_5: J3.7, U1.8 (IO5)
/GPIO_6: J3.8, U1.9 (IO6)
/GPIO_7: J3.9, U1.10 (IO7)
/GPIO_8: J3.10, R7.2, R8.1, U1.11 (IO8)
/GPIO_9: J3.11, U1.12 (IO9)
/GPIO_10: J3.12, U1.13 (IO10)
/GPIO_11: J3.13, U1.14 (IO11)
/GPIO_12: J3.14, U1.15 (IO12)
/GPIO_13: J3.15, U1.16 (IO13)
/GPIO_14: J3.16, U1.17 (IO14)
/GPIO_15: J3.17, U1.18 (IO15)
/GPIO_16: J3.18, U1.19 (IO16)
/GPIO_17: J5.21, U1.20 (IO17); also elsewhere on the board
/GPIO_18: R1.2, U1.21 (IO18)
/GPIO_21: J5.18, U1.24 (IO21)
/GPIO_26: J5.16, U1.25 (IO26)
/GPIO_33: J5.15, U1.27 (IO33)
/GPIO_34: J5.14, U1.28 (IO34)
/GPIO_35: J5.13, U1.29 (IO35)
/GPIO_36: J5.12, U1.30 (IO36)
/GPIO_37: J5.11, U1.31 (IO37)
/GPIO_38: J5.10, U1.32 (IO38)
/GPIO_39: J5.9, U1.33 (IO39)
/GPIO_40: J5.8, U1.34 (IO40)
/GPIO_41: J5.7, U1.35 (IO41)
/GPIO_42: J5.6, U1.36 (IO42)
/GPIO_45: J5.3, U1.39 (IO45)
/GPIO_46: J5.2, U1.40 (IO46)
/RXD0: J5.4, U1.38 (RXD0), U4.2 (TXD)
/TXD0: J5.5, U1.37 (TXD0), U4.3 (RXD)
/VBUSA: D1.1 (K), F1.2, J1.1 (VBUS)
/VBUSC: D1.2 (A), J2.A4B9 (VBUS), J2.B4A9 (VBUS)
/VI: C6.2, C7.2, D3.2 (A), F1.1, J5.22, U2.4 (VDD), U3.3 (VI), U5.5 (VP); also elsewhere on the board
/~DTR: Q2.2, R4.1, U4.13 (~DTR)
/~RTS: Q1.2, R5.1, U4.14 (~RTS)
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.1, C7.1, C8.1, C9.2, C10.1, C11.2, C12.2, J1.4 (GND), J1.5 (Shield), J2.A1B12 (GND), J2.B1A12 (GND), J2.S1 (SHIELD), J2.S2 (SHIELD), J2.S3 (SHIELD), J2.S4 (SHIELD), J3.1, J4.2, J5.1, R3.2, R6.2, R8.2, R12.2, R13.2, R14.2, SW1.1, SW2.1, U1.1 (GND_1), U1.26 (GND_2), U1.42 (GND_3), U1.43 (GND_4), U1.44 (GND_5), U1.45 (GND_6), U1.46 (GND_7), U1.47 (GND_8), U1.48 (GND_9), U1.49 (GND_10), U1.50 (GND_11), U1.51 (GND_12), U2.2 (VSS), U3.1 (GND), U4.1 (GND), U5.2 (GND); also elsewhere on the board
unnamed: C12.1, U4.4 (V3)
unnamed: D2.1 (K), R12.1
unnamed: D3.1 (K), R11.1
unnamed 54: R13.1; also elsewhere on the board
unnamed: Q1.1, R4.2
unnamed: Q2.1, R5.2
unnamed: R14.1, U2.5 (PROG)

Notes on the sheet:
USB-C to UART using CH340C
Auto-Program
Switches
USB-A
ESP32-S2 WROOM RF-Module
Pin Headers
USB-C
SW Pull Up Pins
AMS1117 5V-3.3V Regulator
USB Protection
LiPo Charging Section
ESD Protection Chip
Neopixel
I_charge = 1/R_prog I_charge = 1/4700 I_charge = 213 mA where: R_prog is in Ohms I_charge is in mA
Connect 4.2 rated 1C Lithium Polymer Battery

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
Board: 4 copper layers, 28.1 x 68.3 mm, 48 parts (1 on the bottom side), 58 nets.

Other parts of the board:
LED1: WS2812B-2020; WS2812B2020
U6: DMP2305U-7; SOT103P240X110-3N
svg2mod, svg2mod#2: G***; label

Their connections:
/GPIO_17: LED1.3; also elsewhere on the board
/VI: LED1.4, U6.1, U6.2; also elsewhere on the board
GND: LED1.2; also elsewhere on the board
unnamed 54: LED1.1; also elsewhere on the board

## Commit log

2021-01-15 added rf, switches, basic schematic
2021-01-16 Added SSD1306 and Connectors
2021-01-16 added minor changes
2021-01-17 Added USB to UART
2021-01-18 resolved errors
2021-01-19 Some Changes in Schematic
2021-01-26 made suggested changes
2021-02-01 Made changes in schematics
2021-02-03 minor changes
2021-02-09 Changes in Schematic
2021-02-10 added footprints
2021-02-10 Started Routing
2021-02-11 Updated schematic with proper footprints
2021-02-13 basic routing and placement
2021-02-14 updated schematics
2021-02-15 layout, schematic finalised
2021-02-16 Test Routing Done
2021-02-16 Routing Updates
2021-02-16 Cleaned up routing
2021-02-27 Updated Routing
2021-02-28 optimised routing further
2021-03-06 Switches added
2021-03-10 added 3D models
2021-03-10 added 3D model:switch
2021-03-10 modified and fixed silkscreem
2021-03-13 Silkscreen Modified
2021-03-13 Changes in Routing and Silkscreen
2021-03-13 optimised routing
2021-03-15 made changes- routing and schematic, added silk screen- pin headers
2021-03-17 Changes in PCB
2021-03-17 Updated and optimised routing
2021-03-17 added name, corrected annotations
2021-03-17 addedassets, updateed silkscreen
2021-03-18 Added 3d model for Polyfuse
2021-03-18 changed Polyfuse package 0603->1206
2021-03-19 updated renders, screenshots
2021-03-20 Finalised kicad design
2021-03-20 Added gerbers
2021-03-20 Updated routing to remove vias in pads
2021-03-21 Added Schematic PNG
2021-03-21 Updated Assets
2021-03-21 Addded renders
2021-03-22 added updated renders, datasheets
2021-03-22 Set grid origin and fixed few issues with pcb
2021-03-22 Added 3d renders
2021-03-24 Add kitspace.yaml and 1-click-bom.csv
2021-03-26 Added Battery Charging and Neopixel
2021-05-12 changed bat760 with 1n5819
2021-05-12 Added IP4220CZ6 - ESD Protection Device
2021-05-12 added IP4220CZ6 connections, symbol, footprint
2021-05-13 Added Lipo Charging section symbol, footprint,connections
2021-05-14 Updated 4lyr schematics, datasheets
2021-05-14 Updated datasheets
2021-05-14 Changed Neopixel
2021-05-15 replaces L8050QLT1G with MMBT8050
2021-05-24 Routed 4-layer v.2.1
2021-05-26 Routing 4-Layer v3.0
2021-05-27 Optimised layer distribution and routing in PWR plane
2021-05-27 Fixed undetected board boundaries
2021-05-30 Changes in Routing
2021-05-30 added minor routing changes
2021-06-02 Optimised 4-lyr routing v.4lyr.2
2021-06-03 Routing Optimizations
2021-06-03 Silkscreen Optimizations
2021-06-06 Optimised 4-lyr routing v.4lyr.3
2021-06-07 minor changes to v.4lyr.3
2021-06-08 Silkscreen Modifications
2021-06-08 Modified silkscreen and final changes
2021-06-08 Added asset images
2021-06-08 added schematics
2021-06-08 Added renders
2021-06-08 Updated schematics.PNG
2021-06-09 Added QR Code
2021-06-09 USB C Re-Routing
2021-06-09 Update Assets
2021-06-10 Correcteed qr, rounded corners, added files
2021-06-10 Added images
2021-06-10 Fixed USB:VBUSC route
2021-06-10 Added bill of materials
2021-06-11 Fixed GPIO Number on silkscreen
2021-06-11 Cleaned up renders, gerbers
2021-06-11 Removed redundant files
2021-06-11 Asset fixes
2021-06-13 Set theme jekyll-theme-slate
2021-06-13 Added Github Pages Content
2021-06-13 Added logo
2021-06-13 Rotated board
2021-06-18 Made suggested changes in schematics
2021-06-25 Rotated UsbC and added differential pair
2021-06-27 Made minor changes in routing
2021-06-28 Added missing silkscreen and fixed edgecuts
2021-07-12 Made suggested routing, placement changes
2021-07-14 Updated routing, fixed issue with usb differential pair
2021-07-14 Completed routing 4-layer board
2021-07-14 Updated gerber files
2021-07-15 Routing and placement cleaned
2021-07-15 Modified silkscreen
2021-07-15 Added differential pair to USB circuitry
2021-07-15 Updated silkscreen
2021-07-16 Added assets
2021-07-17 Updated renders, gerbers and assets (#18)
2021-09-30 Rectified neopixel, battery charging errors, updated routing
2021-09-30 Added pMOS DMP230U-7 for power mode select
2021-10-10 Fixed Battery Charging Circuit
2021-10-10 Updated gerbers, renders and assets for v.3
